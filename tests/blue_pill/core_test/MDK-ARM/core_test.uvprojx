# Keil uVision project core_test.uvprojx, settings and files
target core_test (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: core_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,STM32F103xB
  c include: ../Inc;../../common_files/Drivers/STM32F1xx_HAL_Driver/Inc;../../common_files/Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../common_files/Drivers/CMSIS/Include;../../../../../microsila_ll
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group user
    ../Src/user/: leds.c
  group test
    ../Src/test/: byte_buf_test.c crc_test.c utils_test.c byte_buf_test.h crc_test.h utils_test.h dbg_console_test.c
  group Microsila_LL
    ../Inc/: mi_ll_settings.h
    ../../../../: microsila_ll.c
  group Application/User
    ../Src/: main.c stm32f1xx_it.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../common_files/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_gpio.c stm32f1xx_ll_pwr.c stm32f1xx_ll_exti.c stm32f1xx_ll_tim.c stm32f1xx_ll_dma.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
